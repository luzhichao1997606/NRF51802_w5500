# Keil uVision project NET.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: nRF51802_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NET
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: NRF51 NRF51802
  c include: .\LIB\toolchain;.\LIB\drivers_nrf\hal;.\LIB\drivers_nrf\nrf_soc_nosd;.\LIB\drivers_nrf\delay;.\HARDWARE\w5500\Ethernet\W5500;.\HARDWARE\w5500\Ethernet;.\LIB\drivers_nrf\spi_master;..\NRF51802_w5500;.\LIB\drivers_nrf\config;.\LIB\drivers_nrf\gpiote;.\LIB\drivers_nrf\common;.\LIB\libraries\log;.\LIB\libraries\log\src;.\LIB\libraries\util
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group HARDWARE
    ./HARDWARE/Hal/: hal.c
    ./HARDWARE/w5500/Ethernet/W5500/: w5500.c
    ./HARDWARE/w5500/Ethernet/: socket.c wizchip_conf.c
  group LIB
    ./LIB/drivers_nrf/spi_master/: nrf_drv_spi.c
    ./LIB/drivers_nrf/common/: nrf_drv_common.c
  group USER
    ./USER/: main.c nrf_it.c
software components: CMSIS:CORE 5.4.0, Device:Startup 8.32.1
